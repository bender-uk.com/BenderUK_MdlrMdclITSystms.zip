Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-12-09T09:53:11
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort, Port_321304
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcElectricDistributionPoint: NBS_BenderUK_MdclIsltdPwrSplyUnitsIPS_ModularMedicalITSystems:SingleFloor-mountedUnit950mmHigh1500mmOverall, NBS_BenderUK_MdclIsltdPwrSplyUnitsIPS_ModularMedicalITSystems:SingleFloor-mountedUnit950mmHigh1500mmOverall:321304
In: Level 0
Type - Classification: Pr_60_70_64_51 (Uniclass2015); Material: NBS_BenderUK_Steel_RAL9005 (8), NBS_BenderUK_SteelVent_RAL7035, NBS_BenderUK_Steel_RAL7035 (4)
Type - IFC - IfcExportAs: IfcElectricDistributionBoardType; IfcExportType: DISTRIBUTIONBOARD
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_70_64_51:Medical isolated power supply units (IPS); Color: n/a; Finish: n/a; Material: n/a; Shape: Rectangle; Size: n/a; WarrantyDescription: One year,Five year; CodePerformance: n/a; Constituents: n/a; Description: An isolated power supply unit for hospitals.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: marketing@bender-uk.com; ModelNumber: n/a; ModelReference: Modular Medical IT Systems; Name: MedicalIsolatedPowerSupplyUnitsIPS_ModularMedicalITSystems_SingleFloor-mountedUnit950mmHigh1500mmOverall_BenderUK; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_BenderUK_MedicalIsolatedPowerSupplyUnitsIPS_ModularMedicalITSystems_SingleFloor-mountedUnit950mmHigh1500mmOverall; ManufacturerName: Bender UK; ManufacturerURL: www.bender-uk.com; ProductInformation: https://source.thenbs.com/product/-/4eba0358-c2ce-4b70-9222-6f72f1bf60a8/157dc580-3e8e-4696-a30c-fa092a74040e; Uniclass2015Code: Pr_60_70_64_51; Uniclass2015Title: Medical isolated power supply units (IPS); Uniclass2015Version: Products v1.36; Version: 6
Type - NBS_Data - Transformers: Floor standing transformer, 3.15 kVA,Floor standing transformer, 4 kVA,Floor standing transformer, 5 kVA,Floor standing transformer, 6.3 kVA,Floor standing transformer, 8 kVA,Floor standing transformer, 10 kVA; Options: isoMED427 insulation monitoring device and EDS151,ATICS® automatic changeover devices and EDS151 fault location technology; Dimensions: 1500 x 300 x 350 mm; IntegralAccessories: 6 outgoing MCBs/EDS,12 outgoing MCBs/EDS,12 outgoing MCBs,6 outgoing MCBs,6 outgoing MCBs/EDS/PQM,12 outgoing MCBs/EDS/PQM
DistributionPointFunction: DISTRIBUTIONBOARD
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
NBS_Data - Mounting: Floor mounted
